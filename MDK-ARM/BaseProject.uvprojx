# Keil uVision project BaseProject.uvprojx, settings and files
target BaseProject (6210000::V6.21::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: BaseProject +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_MATRIX,ARM_MATH_LOOPUNROLL,ARM_MATH_CM7,DATA_IN_ExtSDRAM,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/1.17.0/Include;../Drivers/CMSIS/DSP/1.17.0/Include/dsp;../Drivers/CMSIS/DSP/1.17.0/PrivateInclude;../Drivers/CMSIS/FreeRTOS/Include;../Drivers/CMSIS/FreeRTOS/portable/GCC/ARM_CM7/r0p1;../Drivers/SYSTEM/Inc;../BSP/Inc;../BSP/Drivers/Inc;../APP/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\BaseProject\BaseProject.sct
  group Startup
    ./: startup_stm32h743xx.s
  group User/Core
    ../Core/Src/: main.c gpio.c fmc.c ltdc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/Src/: sys.c delay.c
  group Drivers/CMSIS/DSP
    ../Drivers/CMSIS/DSP/1.17.0/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/ControllerFunctions/: ControllerFunctions.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    ../Drivers/CMSIS/DSP/1.17.0/Source/WindowFunctions/: WindowFunctions.c
  group Drivers/CMSIS/FreeRTOS/src
    ../Drivers/CMSIS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/CMSIS/FreeRTOS/port
    ../Drivers/CMSIS/FreeRTOS/portable/GCC/ARM_CM7/r0p1/: port.c
    ../Drivers/CMSIS/FreeRTOS/portable/MemMang/: heap_4.c
  group BSP/Core
    ../BSP/Src/: bsp_fmc_sdram_init.c bsp_ltdc.c bsp_usart.c
  group BSP/Drivers
    ../BSP/Drivers/Src/: lcd.c lcd_use.c
  group APP/Core
    ../APP/Src/: os_task.c
software components: CMSIS:CORE 6.2.0
